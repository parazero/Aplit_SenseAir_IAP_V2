<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\SenseAirNew_IAP.ewp</path>
  </project>
  <batchBuild />
</workspace>
